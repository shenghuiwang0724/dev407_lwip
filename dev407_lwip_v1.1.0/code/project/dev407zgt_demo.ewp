# IAR project dev407zgt_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\fw_lib\STM32F4xx_StdPeriph_Driver\inc; ..\platform\drivers\inc; ..\fw_lib\CMSIS\Device\ST\STM32F4xx\Include; ..\fw_lib\CMSIS\Include; ..\fw_lib\STM32F4x7_ETH_Driver\inc; ..\platform\devs\inc; ..\platform\drivers\inc; ..\common; ..\lwip\lwip_app\lwip_comm; ..\lwip\lwip-1.4.1\src\include; ..\lwip\lwip-1.4.1\src\include\ipv4; ..\lwip\lwip-1.4.1\src\include\netif; ..\lwip\lwip_arch; ..\ucos-iii\ucos_bsp; ..\ucos-iii\ucos_cfg; ..\ucos-iii\ucos_core; ..\ucos-iii\ucos_cpu; ..\ucos-iii\ucos_cpu\ARM-Cortex-M4\IAR; ..\ucos-iii\ucos_lib; ..\ucos-iii\ucos_lib\Ports\ARM-Cortex-M4\IAR; ..\ucos-iii\ucos_port; ..\network; ..\lwip\lwip_arch\ucos_arch
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dev407zgt_demo.srec
  ILINK.IlinkOutputFile: dev407zgt_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../common/: malloc.c printf.c
  group devs/src
    ../platform/devs/src/: lan8720.c sram.c
  group drivers/src
    ../platform/drivers/src/: led.c main.c stm32f4xx_it.c systick.c timer.c usart.c
  group fw_libs/CMSIS
    ../fw_lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group fw_libs/STM32F4x7_ETH_Driver
    ../fw_lib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group fw_libs/STM32F4xx_StdPeriph_Driver
    ../fw_lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group lwip_app
    ../lwip/lwip_app/lwip_comm/: debug_printf.c lwip_comm.c sys_task.c
  group lwip_arch
    ../lwip/lwip_arch/ucos_arch/: sys_arch.c
  group lwip_lib/api
    ../lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_lib/core
    ../lwip/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip_lib/netif
    ../lwip/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group network
    ../network/: netconn_udp.c
  group startup
    ../fw_lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group ucos-iii/ucos_bsp
    ../ucos-iii/ucos_bsp/: bsp.c
  group ucos-iii/ucos_cfg
    ../ucos-iii/ucos_cfg/: os_app_hooks.c
  group ucos-iii/ucos_core
    ../ucos-iii/ucos_core/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucos-iii/ucos_cpu
    ../ucos-iii/ucos_cpu/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../ucos-iii/ucos_cpu/: cpu_core.c
  group ucos-iii/ucos_lib
    ../ucos-iii/ucos_lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../ucos-iii/ucos_lib/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group ucos-iii/ucos_port
    ../ucos-iii/ucos_port/: os_cpu_a.asm os_cpu_c.c
