<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dev407zgt_demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


